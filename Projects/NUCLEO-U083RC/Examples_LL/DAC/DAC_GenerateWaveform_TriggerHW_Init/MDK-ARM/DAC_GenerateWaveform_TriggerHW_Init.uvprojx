# Keil uVision project DAC_GenerateWaveform_TriggerHW_Init.uvprojx, settings and files
target DAC_GenerateWaveform_TriggerHW_Init (6190000::V6.19::ARMCLANG)
  device: STM32U083RCTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: DAC_GenerateWaveform_TriggerHW_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=4000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=48000000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,ART_ACCELERATOR_ENABLE=0,STM32U083xx
  c include: ../Inc;../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_ll_exti.c stm32u0xx_ll_utils.c stm32u0xx_ll_gpio.c stm32u0xx_ll_dac.c stm32u0xx_ll_dma.c stm32u0xx_ll_pwr.c stm32u0xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
software components: CMSIS:CORE 4.3.0
