# IAR project USART_SyncCommunication_FullDuplex_DMA_Init.ewp, settings and files
configuration USART_SyncCommunication_FullDuplex_DMA_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=4000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=4000000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; ART_ACCELERATOR_ENABLE=0; STM32U083xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_SyncCommunication_FullDuplex_DMA_Init.hex
  ILINK.IlinkOutputFile: USART_SyncCommunication_FullDuplex_DMA_Init.out
  ILINK.IlinkIcfFile: stm32u083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_ll_dma.c stm32u0xx_ll_exti.c stm32u0xx_ll_gpio.c stm32u0xx_ll_pwr.c stm32u0xx_ll_rcc.c stm32u0xx_ll_spi.c stm32u0xx_ll_usart.c stm32u0xx_ll_utils.c
