# Keil uVision project CRYP_GCM_GMAC_CCM_Suspension.uvprojx, settings and files
target CRYP_GCM_GMAC_CCM_Suspension (6190000::V6.19::ARMCLANG)
  device: STM32U083RCTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: CRYP_GCM_GMAC_CCM_Suspension +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U083xx,USE_HAL_CRYP_SUSPEND_RESUME
  c include: ../Inc;../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U0xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U0xx_Nucleo/: stm32u0xx_nucleo.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cryp.c stm32u0xx_hal_cryp_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
software components: CMSIS:CORE 4.3.0
