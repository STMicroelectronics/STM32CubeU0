# IAR project OPAMP_Calibration.ewp, settings and files
configuration OPAMP_Calibration (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U083xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U0xx_Nucleo; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OPAMP_Calibration.hex
  ILINK.IlinkOutputFile: OPAMP_Calibration.out
  ILINK.IlinkIcfFile: stm32u083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U0xx_Nucleo/: stm32u0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_ll_opamp.c stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_dac.c stm32u0xx_hal_dac_ex.c stm32u0xx_hal_opamp.c stm32u0xx_hal_opamp_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
