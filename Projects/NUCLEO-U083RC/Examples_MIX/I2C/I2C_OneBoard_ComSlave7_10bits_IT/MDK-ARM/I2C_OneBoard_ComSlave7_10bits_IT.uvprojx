# Keil uVision project I2C_OneBoard_ComSlave7_10bits_IT.uvprojx, settings and files
target I2C_OneBoard_ComSlave7_10bits_IT (6140001::V6.14.1::ARMCLANG)
  device: STM32U083RCTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: I2C_OneBoard_ComSlave7_10bits_IT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32U083xx
  c include: ../Inc;../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U0xx_Nucleo
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U0xx_Nucleo/: stm32u0xx_nucleo.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_ll_exti.c stm32u0xx_ll_utils.c stm32u0xx_ll_gpio.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_ll_i2c.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
software components: CMSIS:CORE 4.3.0
