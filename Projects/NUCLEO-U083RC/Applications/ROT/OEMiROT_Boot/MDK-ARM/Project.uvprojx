# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U083RC_OEMiROT_Boot (6190000::V6.19::ARMCLANG)
  device: STM32U083RCIx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20002000,0x2000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv6-m -E -P -xc -DSTM32U083xx -DBL2 -I..\Inc -I..\..\..\..\..\..\Drivers\CMSIS\Include -I..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include -I..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc ..\Src\image_macros_to_preprocess_bl2.c -o image_macros_preprocessed_bl2.c
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\OEMiROT_Boot.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U083xx,USE_HAL_DRIVER,NDEBUG,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<config-boot.h>,MCUBOOT_DOUBLE_SIGN_VERIF,FLOW_CONTROL,BL2,DEFAULT_UART_BAUDRATE=115200,OEMIROT_DEV_MODE,BOOT_MAX_ALIGN=16,MULADDC_CANNOT_USE_R7
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include;..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include;..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\common;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\tinycrypt\lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\stm32u0xx_bl2.sct
  link misc: --predefine=-I../Inc/
--predefine=-DBL2
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Source/Templates/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_rng.c stm32u0xx_hal_rng_ex.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c
  group Application/MDK-ARM
    ../Src/: startup_stm32u0xx.c
  group Application/User
    ../Src/: bl2_nv_services.c boot_hal.c keys.c keys_map.c stm32u0xx_hal_msp.c low_level_com.c low_level_device.c low_level_flash.c low_level_rng.c low_level_security.c tick.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c asn1write.c bignum.c constant_time.c cipher.c cipher_wrap.c hmac_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c hkdf.c md.c memory_buffer_alloc.c platform.c platform_util.c sha256.c bignum_core.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
