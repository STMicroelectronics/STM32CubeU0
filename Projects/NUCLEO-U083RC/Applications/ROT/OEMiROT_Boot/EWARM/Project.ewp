# IAR project Project.ewp, settings and files
configuration NUCLEO-U083RC_OEMiROT_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32U083xx; USE_HAL_DRIVER; NDEBUG; MCUBOOT_TARGET_CONFIG=<flash_layout.h>; MBEDTLS_CONFIG_FILE=<config-boot.h>; MCUBOOT_DOUBLE_SIGN_VERIF; BL2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; OEMIROT_DEV_MODE; BOOT_MAX_ALIGN=16; FLOW_CONTROL
  ICCARM.IExtraOptions: -DNO_TYPEOF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\tinycrypt\lib\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMiROT_Boot.bin
  prebuild: prebuild.cmd "$PROJ_DIR$"
  postbuild: cmd /C "cmd /C postbuild.bat""
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: bl2_nv_services.c boot_hal.c keys.c keys_map.c low_level_com.c low_level_device.c low_level_flash.c low_level_rng.c low_level_security.c startup_stm32u0xx.c stm32u0xx_hal_msp.c tick.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_rng.c stm32u0xx_hal_rng_ex.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c bignum.c cipher.c constant_time.c ctr_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c hkdf.c md.c memory_buffer_alloc.c platform.c platform_util.c rsa.c rsa_internal.c sha256.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
