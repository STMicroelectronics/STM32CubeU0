# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U083RC_OEMiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32U083RCIx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20002000,0x2000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\rot_app.bin"
  AfterMake: postbuild.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U083xx,USE_HAL_DRIVER
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include;..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32u0xx_app.sct
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: com.c common.c data.c fw_update_app.c low_level_device.c low_level_flash.c main.c stm32u0xx_it.c ymodem.c
software components: CMSIS:CORE 5.6.0
