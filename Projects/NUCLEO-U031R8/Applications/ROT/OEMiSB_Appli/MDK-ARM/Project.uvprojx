# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U031R8_OEMiSB_Appli (6190000::V6.19::ARMCLANG)
  device: STM32U031R8Tx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20002000,0x2000) IROM1(0x08000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: $PROJ_FNAME$
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\OEMiSB_Appli.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U031xx,USE_HAL_DRIVER,USE_FULL_ASSERT
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32U0xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32u0xx_app.sct
  group Doc
    ../: README.md
  group Applications/User
    ../Src/: main.c stm32u0xx_it.c
  group Applications/MDK-ARM
    ./: startup_stm32u031xx.s
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_rng.c stm32u0xx_hal_rng_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
software components: CMSIS:CORE 4.3.0
