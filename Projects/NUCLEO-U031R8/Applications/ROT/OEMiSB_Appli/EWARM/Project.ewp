# IAR project Project.ewp, settings and files
configuration NUCLEO-U031R8_OEMiSB_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32U031R8 ST STM32U031R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U031xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32U0xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMiSB_Appli.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32u031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/User
    ../Src/: main.c stm32u0xx_it.c
  group Applications/EWARM
    ./: startup_stm32u031xx.s
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_hal_wwdg.c stm32u0xx_hal_rng.c stm32u0xx_hal_rng_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Doc
    ../: README.md
