# IAR project Project.ewp, settings and files
configuration NUCLEO-U031R8_OEMiSB_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32U031R8 ST STM32U031R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U031xx; USE_HAL_DRIVER; USE_FULL_ASSERT; MBEDTLS_CONFIG_FILE="mbed-crypto_config.h"; FLOW_CONTROL; FIH_ENABLE_DELAY
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ..\..\..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32U0xx_Nucleo; ../../../../../../Middlewares/Third_Party/mbed-crypto/include; ../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMiSB_Boot.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32u031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/User
    ../Src/: main.c stm32u0xx_it.c boot.c low_level_rng.c low_level_security.c
  group Applications/EWARM
    ./: startup_stm32u031xx.s
  group Doc
    ../: README.md
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_cortex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_rng.c stm32u0xx_hal_rng_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: sha256.c platform_util.c
