# IAR project ADC_SingleConversion_TriggerTimer_DMA.ewp, settings and files
configuration ADC_SingleConversion_TriggerTimer_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32U031R8 ST STM32U031R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U031xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U0xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_SingleConversion_TriggerTimer_DMA.hex
  ILINK.IlinkOutputFile: ADC_SingleConversion_TriggerTimer_DMA.out
  ILINK.IlinkIcfFile: stm32u031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u031xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U0xx_Nucleo/: stm32u0xx_nucleo.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_exti.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_ll_adc.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
