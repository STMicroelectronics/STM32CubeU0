# IAR project SPI_TwoBoards_FullDuplex_DMA_Master_Init.ewp, settings and files
configuration SPI_TwoBoards_FullDuplex_DMA_Master_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32U031R8 ST STM32U031R8
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32U031xx; HSE_VALUE=4000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=48000000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; ART_ACCELERATOR_ENABLE=0
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_TwoBoards_FullDuplex_DMA_Master_Init.hex
  ILINK.IlinkOutputFile: SPI_TwoBoards_FullDuplex_DMA_Master_Init.out
  ILINK.IlinkIcfFile: stm32u031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u031xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_ll_dma.c stm32u0xx_ll_exti.c stm32u0xx_ll_gpio.c stm32u0xx_ll_pwr.c stm32u0xx_ll_spi.c stm32u0xx_ll_utils.c
