# IAR project Project.ewp, settings and files
configuration STM32U083C-DK_Templates_LL (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083RC ST STM32U083RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_LL_DRIVER; STM32U083xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32U0xx\Include; ..\..\..\..\Drivers\STM32U0xx_HAL_Driver\Inc; ..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c stm32u0xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_LL_Driver
    ../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_ll_adc.c stm32u0xx_ll_comp.c stm32u0xx_ll_crc.c stm32u0xx_ll_crs.c stm32u0xx_ll_dac.c stm32u0xx_ll_dma.c stm32u0xx_ll_exti.c stm32u0xx_ll_gpio.c stm32u0xx_ll_i2c.c stm32u0xx_ll_lptim.c stm32u0xx_ll_lpuart.c stm32u0xx_ll_opamp.c stm32u0xx_ll_pwr.c stm32u0xx_ll_rcc.c stm32u0xx_ll_rng.c stm32u0xx_ll_rtc.c stm32u0xx_ll_spi.c stm32u0xx_ll_tim.c stm32u0xx_ll_usart.c stm32u0xx_ll_usb.c stm32u0xx_ll_utils.c
