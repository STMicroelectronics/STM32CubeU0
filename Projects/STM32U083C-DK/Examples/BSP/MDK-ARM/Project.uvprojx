# Keil uVision project Project.uvprojx, settings and files
target STM32U083-DK_BSP (6190000::V6.19::ARMCLANG)
  device: STM32U083RCTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20002000,0x2000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BSP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U083xx,USE_HAL_DRIVER,USE_FULL_ASSERT
  c misc: -Wno-invalid-source-encoding
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../../../../../Drivers/STM32U0xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STM32U083C-DK;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/stts22h
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32u083xx.s
  group Application
    ../Src/: joystick.c lcdglass.c led.c main.c stm32u0xx_it.c tempsensor.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32U083C-DK
    ../../../../../Drivers/BSP/STM32U083C-DK/: stm32u083c_discovery.c stm32u083c_discovery_bus.c stm32u083c_discovery_env_sensors.c stm32u083c_discovery_glass_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_gpio.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_hal_lcd.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c
software components: CMSIS:CORE 5.6.0
