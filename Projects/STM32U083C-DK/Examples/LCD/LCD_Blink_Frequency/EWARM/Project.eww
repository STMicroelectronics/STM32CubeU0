<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LCD_Blink_Frequency.ewp</path>
  </project>
  <batchBuild />
</workspace>
