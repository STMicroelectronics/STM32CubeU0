# IAR project TouchSensing_1touchkey_LowPower.ewp, settings and files
configuration TouchSensing_1touchkey_LowPower (ARM, debug)
  General.OGChipSelectEditMenu: STM32U083MC ST STM32U083MC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U083xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src; ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32U0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U083C-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TouchSensing_1touchkey_LowPower.hex
  ILINK.IlinkOutputFile: TouchSensing_1touchkey_LowPower.out
  ILINK.IlinkIcfFile: stm32u083xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u083xx.s
  group Application/User
    ../Src/: main.c touchsensing.c tsl_user.c stmCriticalSection.c stm32u0xx_it.c stm32u0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U083C-DK
    ../../../../../../Drivers/BSP/STM32U083C-DK/: stm32u083c_discovery.c stm32u083c_discovery_glass_lcd.c
  group Drivers/STM32U0xx_HAL_Driver
    ../../../../../../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_hal_lcd.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_ll_adc.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_comp.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_cortex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_tsc.c
  group Drivers/CMSIS
    ../Src/: system_stm32u0xx.c
  group Middlewares/TouchSensing
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_acq_tsc.c tsl_globals.c tsl_touchkey.c tsl_acq.c tsl_dxs.c tsl_linrot.c tsl_ecs.c tsl_object.c tsl_time.c tsl_filter.c
