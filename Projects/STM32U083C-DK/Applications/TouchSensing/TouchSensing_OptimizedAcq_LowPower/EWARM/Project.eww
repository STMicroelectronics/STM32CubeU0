<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TouchSensing_OptimizedAcq_LowPower.ewp</path>
  </project>
  <batchBuild />
</workspace>
