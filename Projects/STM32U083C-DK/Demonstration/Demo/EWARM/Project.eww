<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32U083C_DK_Demo.ewp</path>
  </project>
  <batchBuild />
</workspace>
